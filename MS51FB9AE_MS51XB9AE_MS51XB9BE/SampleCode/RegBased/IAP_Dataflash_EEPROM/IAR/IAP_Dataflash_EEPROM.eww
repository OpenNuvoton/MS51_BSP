<?xml version='1.0' encoding='UTF-8'?>
<workspace>
  <project>
    <path>$WS_DIR$\IAP_Dataflash_EEPROM.ewp</path>
  </project>
  <batchBuild />
</workspace>