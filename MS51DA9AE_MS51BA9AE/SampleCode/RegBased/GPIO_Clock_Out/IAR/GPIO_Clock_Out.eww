<?xml version='1.0' encoding='UTF-8'?>
<workspace>
    <project>
        <path>$WS_DIR$\GPIO_Clock_Out.ewp</path>
    </project>
    <batchBuild />
</workspace>