<?xml version='1.0' encoding='UTF-8'?>
<workspace>
  <project>
    <path>$WS_DIR$\IAP_Dataflash_EEPROM_SPROM.ewp</path>
  </project>
  <batchBuild />
</workspace>