<?xml version='1.0' encoding='UTF-8'?>
<workspace>
    <project>
        <path>$WS_DIR$\Timer0_Interrupt.ewp</path>
    </project>
    <batchBuild />
</workspace>