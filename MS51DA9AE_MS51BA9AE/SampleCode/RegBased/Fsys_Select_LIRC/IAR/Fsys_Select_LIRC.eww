<?xml version='1.0' encoding='UTF-8'?>
<workspace>
    <project>
        <path>$WS_DIR$\Fsys_Select_LIRC.ewp</path>
    </project>
    <batchBuild />
</workspace>