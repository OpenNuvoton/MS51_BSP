<?xml version='1.0' encoding='UTF-8'?>
<workspace>
  <project>
    <path>$WS_DIR$\SPI_Flash_Read_Write.ewp</path>
  </project>
  <batchBuild />
</workspace>