<?xml version='1.0' encoding='UTF-8'?>
<workspace>
  <project>
    <path>$WS_DIR$\IAP_AP_program_LD.ewp</path>
  </project>
  <batchBuild />
</workspace>