<?xml version='1.0' encoding='UTF-8'?>
<workspace>
    <project>
        <path>$WS_DIR$\UART4_Parity_Bit.ewp</path>
    </project>
    <batchBuild />
</workspace>