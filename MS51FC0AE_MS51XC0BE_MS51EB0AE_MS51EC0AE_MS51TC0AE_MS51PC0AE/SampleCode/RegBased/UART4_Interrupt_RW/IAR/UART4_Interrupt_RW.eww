<?xml version='1.0' encoding='UTF-8'?>
<workspace>
    <project>
        <path>$WS_DIR$\UART4_Interrupt_RW.ewp</path>
    </project>
    <batchBuild />
</workspace>