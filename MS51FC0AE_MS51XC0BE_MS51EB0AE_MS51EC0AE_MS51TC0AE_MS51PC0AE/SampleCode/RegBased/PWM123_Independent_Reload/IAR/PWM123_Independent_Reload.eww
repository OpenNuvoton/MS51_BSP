<?xml version='1.0' encoding='UTF-8'?>
<workspace>
  <project>
    <path>$WS_DIR$\PWM123_Independent_Reload.ewp</path>
  </project>
  <batchBuild />
</workspace>