<?xml version='1.0' encoding='UTF-8'?>
<workspace>
  <project>
    <path>$WS_DIR$\IAP_program_CONFIG.ewp</path>
  </project>
  <batchBuild />
</workspace>