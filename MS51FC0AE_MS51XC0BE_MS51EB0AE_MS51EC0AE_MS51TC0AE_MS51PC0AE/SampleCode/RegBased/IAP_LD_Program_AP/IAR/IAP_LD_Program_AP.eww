<?xml version='1.0' encoding='UTF-8'?>
<workspace>
  <project>
    <path>$WS_DIR$\IAP_LD_Program_AP.ewp</path>
  </project>
  <batchBuild />
</workspace>