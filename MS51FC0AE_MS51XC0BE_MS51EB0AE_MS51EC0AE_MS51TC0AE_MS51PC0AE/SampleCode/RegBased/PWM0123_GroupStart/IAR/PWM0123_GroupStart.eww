<?xml version='1.0' encoding='UTF-8'?>
<workspace>
  <project>
    <path>$WS_DIR$\PWM0123_GroupStart.ewp</path>
  </project>
  <batchBuild />
</workspace>